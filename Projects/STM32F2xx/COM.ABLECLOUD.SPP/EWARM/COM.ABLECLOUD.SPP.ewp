# IAR project COM.ABLECLOUD.SPP.ewp, settings and files
configuration MiCOKit-3162 (ARM)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; ZC_MODULE_VERSION=0; ZC_MODULE_TYPE=5; xZC_MODULE_DEV
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.ABLECLOUD.SPP; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3162; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M3; ..\..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\External\FatFs\src\drivers; ..\..\..\..\External\FatFs\src; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform; ..\..\..\..\Platform\MCU; ..\..\..\..\Demos\COM.ABLECLOUD.SPP\ZC\inc\zc; ..\..\..\..\Demos\COM.ABLECLOUD.SPP\ZC\inc\aes; ..\..\..\..\Demos\COM.ABLECLOUD.SPP\ZC\inc\tropicssl; ..\..\..\..\Demos\COM.ABLECLOUD.SPP\Adaptor; ..\..\..\..\Demos\COM.ABLECLOUD.SPP\AC\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: COM.ABLECLOUD.SPP.bin
  ILINK.IlinkOutputFile: COM.ABLECLOUD.SPP.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3162\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MiCOKit-F205 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.ABLECLOUD.SPP; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-F205; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M3; ..\..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\External\FatFs\src\drivers; ..\..\..\..\External\FatFs\src; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\MCU
  ICCARM.IccLang: 0
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-F205\micoLinkerForIAR.icf
configuration MiCOKit-3161 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.ABLECLOUD.SPP; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3161; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M3; ..\..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\External\FatFs\src\drivers; ..\..\..\..\External\FatFs\src; ..\..\..\..\Platform\Drivers\spi_flash
  ICCARM.IccLang: 0
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3161\micoLinkerForIAR.icf
  group AC
    ../../../../Demos/COM.ABLECLOUD.SPP/AC/src/: ac_api.c ac_hal.c
  group Application
    ../../../../Demos/COM.ABLECLOUD.SPP/: MICOAppEntrance.c UartRecv.c
  group Board/MiCOKit-3162
    ../../../../Board/MiCOKit-3162/: platform.c platform.h platform_config.h
  group External/Curve25519
    ../../../../External/Curve25519/: curve25519-donna.c
  group External/FatFs/Core
    ../../../../External/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group External/FatFs/Drivers
    ../../../../External/FatFs/src/drivers/: usbh_diskio.c
  group External/FatFs/Options
    ../../../../External/FatFs/src/option/: syscall.c unicode.c
  group External/GladmanAES
    ../../../../External/GladmanAES/: aes_modes.c aescrypt.c aeskey.c aestab.c gf128mul.c
  group External/JSON-C
    ../../../../External/JSON-C/: arraylist.c debug.c json.h json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group External/SHAUtils
    ../../../../External/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group MICO
    ../../../../MICO/: MICOCli.c MICOConfigMenu.c MICODefine.h MICOEntrance.c MICONotificationCenter.c MICOParaStorage.c MICOSystemMonitor.c
  group MICO/AirKiss
    ../../../../MICO/Airkiss/: Airkiss.c Airkiss_CM3_Debug.a Airkiss_CM3_Release.a
  group MICO/EasyLink
    ../../../../MICO/EasyLink/: EasyLink.c
    ../../../../MICO/SoftAP/: EasyLinkSoftAP.c
  group MICO/Library
    ../../../../MICO/Library/: MICOConfig.c mxchipWNet_cm3_sdio.a mxchipWNet_cm3_spi.a
    ../../../../MICO/Library/RF driver/: wlan_firmware.c
  group MICO/WAC
    ../../../../MICO/WAC/: MFi_WAC_CM3_Debug.a MFi_WAC_CM3_Release.a
  group MICO/WPS
    ../../../../MICO/WPS/: WPS.c
  group Platform/Cortex-M3
    ../../../../Platform/Cortex-M3/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/MFiAuth
    ../../../../Platform/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/Drivers/SPI Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/Drivers/STM32_USB_Host_Library/Class/MSC
    ../../../../Platform/Drivers/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Platform/Drivers/STM32_USB_Host_Library/Core
    ../../../../Platform/Drivers/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Platform/EWARM
    ../../../../Platform/EWARM/: Retarget.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STM32F2xx
    ../../../../Platform/MCU/STM32F2xx/: platform_init.c
  group Platform/MCU/STM32F2xx/EWARM
    ../../../../Platform/MCU/STM32F2xx/EWARM/: startup_stm32f2xx_EWARM.s
  group Platform/MCU/STM32F2xx/Peripherals
    ../../../../Platform/MCU/STM32F2xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/MCU/STM32F2xx/Peripherals/Libraries/STM32F2xx_HAL_Driver
    ../../../../Platform/MCU/STM32F2xx/peripherals/Libraries/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_hcd.c stm32f2xx_ll_usb.c
  group Platform/MCU/STM32F2xx/Peripherals/Libraries/STM32F2xx_StdPeriph_Driver
    ../../../../Platform/MCU/STM32F2xx/peripherals/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Platform/MCU/STM32F2xx/wlan_bus_driver
    ../../../../Platform/MCU/STM32F2xx/wlan_bus_driver/: read_wifi_firmware.c wlan_bus_sdio.c wlan_bus_spi.c wlan_platform.c
  group Support
    ../../../../Support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group ZC/Adaptor
    ../../../../Demos/COM.ABLECLOUD.SPP/Adaptor/: zc_mx_adpter.c
  group ZC/AES
    ../../../../Demos/COM.ABLECLOUD.SPP/ZC/src/aes/: aes_cbc.c aes_core.c
  group ZC/CRC
    ../../../../Demos/COM.ABLECLOUD.SPP/ZC/src/crc/: crc.c
  group ZC/TROPICSSL
    ../../../../Demos/COM.ABLECLOUD.SPP/ZC/src/tropicssl/: bignum.c rsa.c
  group ZC/ZC
    ../../../../Demos/COM.ABLECLOUD.SPP/ZC/src/zc/: zc_bc.c zc_client_manager.c zc_cloud_event.c zc_common.c zc_configuration.c zc_message_queue.c zc_moudle_manager.c zc_protocol_controller.c zc_sec_engine.c zc_timer.c
