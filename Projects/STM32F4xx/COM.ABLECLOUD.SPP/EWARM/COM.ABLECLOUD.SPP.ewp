# IAR project COM.ABLECLOUD.SPP.ewp, settings and files
configuration MiCOKit-3165 (ARM)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=26000000; ZC_MODULE_VERSION=0; ZC_MODULE_TYPE=5; ZC_MODULE_DEV
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.ABLECLOUD.SPP; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3165; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Demos\COM.ABLECLOUD.SPP\ZC\inc\zc; ..\..\..\..\Demos\COM.ABLECLOUD.SPP\ZC\inc\aes; ..\..\..\..\Demos\COM.ABLECLOUD.SPP\ZC\inc\tropicssl; ..\..\..\..\Demos\COM.ABLECLOUD.SPP\Adaptor; ..\..\..\..\Demos\COM.ABLECLOUD.SPP\AC\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: COM.ABLECLOUD.SPP.bin
  ILINK.IlinkOutputFile: COM.ABLECLOUD.SPP.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3165\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MiCOKit-3288 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=16000000
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.ABLECLOUD.SPP; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3288; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3288\micoLinkerForIAR.icf
configuration EMW5288 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=16000000
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.ABLECLOUD.SPP; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\EMW5288; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash
  ILINK.IlinkIcfFile: ..\..\..\..\Board\EMW5288\micoLinkerForIAR.icf
  group AC
    ../../../../Demos/COM.ABLECLOUD.SPP/AC/src/: ac_api.c ac_hal.c
  group Application
    ../../../../Demos/COM.ABLECLOUD.SPP/: MICOAppEntrance.c UartRecv.c
  group Board/MiCOKit-3165
    ../../../../Board/MiCOKit-3165/: platform.c platform.h platform_config.h
  group External/Curve25519
    ../../../../External/Curve25519/: curve25519-donna.c
  group External/FatFs/Core
    ../../../../External/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group External/FatFs/Drivers
    ../../../../External/FatFs/src/drivers/: usbh_diskio.c
  group External/FatFs/Options
    ../../../../External/FatFs/src/option/: syscall.c unicode.c
  group External/GladmanAES
    ../../../../External/GladmanAES/: aes_modes.c aescrypt.c aeskey.c aestab.c gf128mul.c
  group External/JSON-C
    ../../../../External/JSON-C/: arraylist.c debug.c json.h json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group External/SHAUtils
    ../../../../External/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group Library
    ../../../../MICO/Library/: MICOConfig.c mxchipWNet_cm4f_8801.a mxchipWNet_cm4f_sdio.a
    ../../../../MICO/Library/RF driver/: wlan_firmware.c
  group MICO
    ../../../../MICO/: MICOCli.c MICOConfigMenu.c MICODefine.h MICOEntrance.c MICONotificationCenter.c MICOParaStorage.c MICOSystemMonitor.c
  group MICO/AirKiss
    ../../../../MICO/Airkiss/: Airkiss.c Airkiss_CM3_Debug.a Airkiss_CM3_Release.a
  group MICO/EasyLink
    ../../../../MICO/EasyLink/: EasyLink.c
    ../../../../MICO/SoftAP/: EasyLinkSoftAP.c
  group MICO/WAC
    ../../../../MICO/WAC/: MFi_WAC_CM3_Debug.a MFi_WAC_CM3_Release.a
  group MICO/WPS
    ../../../../MICO/WPS/: WPS.c
  group Platform
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/MFiAuth
    ../../../../Platform/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/Drivers/SPI Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/EWARM
    ../../../../Platform/EWARM/: Retarget.c
  group Platform/STM32F4xx
    ../../../../Platform/MCU/STM32F4xx/: platform_init.c
  group Platform/STM32F4xx/EWARM
    ../../../../Platform/MCU/STM32F4xx/EWARM/: startup_stm32f411xe_IAR.s
  group Platform/STM32F4xx/Peripherals
    ../../../../Platform/MCU/STM32F4xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/STM32F4xx/Peripherals/Libraries
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/: system_stm32f4xx.c
  group Platform/STM32F4xx/Peripherals/Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Platform/STM32F4xx/Wi-Fi_Bus_Driver
    ../../../../Platform/MCU/STM32F4xx/wlan_bus_driver/: read_wifi_firmware.c wlan_bus_sdio.c wlan_bus_spi.c wlan_platform.c
  group Support
    ../../../../Support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group ZC/Adaptor
    ../../../../Demos/COM.ABLECLOUD.SPP/Adaptor/: zc_mx_adpter.c
  group ZC/AES
    ../../../../Demos/COM.ABLECLOUD.SPP/ZC/src/aes/: aes_cbc.c aes_core.c
  group ZC/CRC
    ../../../../Demos/COM.ABLECLOUD.SPP/ZC/src/crc/: crc.c
  group ZC/TROPICSSL
    ../../../../Demos/COM.ABLECLOUD.SPP/ZC/src/tropicssl/: bignum.c rsa.c
  group ZC/ZC
    ../../../../Demos/COM.ABLECLOUD.SPP/ZC/src/zc/: zc_bc.c zc_client_manager.c zc_cloud_event.c zc_common.c zc_configuration.c zc_message_queue.c zc_moudle_manager.c zc_protocol_controller.c zc_sec_engine.c zc_timer.c
